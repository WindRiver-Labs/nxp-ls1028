#
# Copyright (C) 2014 Wind River Systems, Inc.
#
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_nxp-ls1028 += "file://xorg.conf"
