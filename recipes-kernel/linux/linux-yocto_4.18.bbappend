require linux-yocto-nxp-ls1028.inc

KBRANCH_nxp-ls1028  = "v4.18/standard/nxp-ls1028"
